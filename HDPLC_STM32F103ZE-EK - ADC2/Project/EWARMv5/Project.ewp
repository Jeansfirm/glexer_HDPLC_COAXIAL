# IAR project Project.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\..\Source\inc; ..\..\Libraries\CMSIS\Core\CM3; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\uIP-1.0\uip; ..\..\Libraries\uIP-1.0\apps\webserver; ..\..\Source\src\uIP_DM9000
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: STM32F103ZE-EK.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CpuRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: stm32f10x_ram.icf
configuration ExtSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: stm32f10x_extsram.icf
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group EWARMv5
    ../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group uIP-1.0
    ../../Libraries/uIP-1.0/uip/: psock.c timer.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group uIP-App
    ../../Source/src/uIP_DM9000/: clock-arch.c dm9k_uip.c tapdev.c
    ../../Source/src/: tcp_demo.c
  group User
    ../../Source/src/: button.c main.c stm32f10x_it.c systick.c usart_printf.c
